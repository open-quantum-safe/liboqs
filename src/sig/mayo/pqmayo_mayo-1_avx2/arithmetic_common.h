// SPDX-License-Identifier: Apache-2.0

#ifndef ARITHMETIC_COMMON_H
#define ARITHMETIC_COMMON_H

#include <stdint.h>
#include <immintrin.h>
#include <mem.h>

#define K_OVER_2 ((K_MAX+1)/2)

static const unsigned char __gf16_mulbase[128] __attribute__((aligned(32))) = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x00, 0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x03, 0x01, 0x07, 0x05, 0x0b, 0x09, 0x0f, 0x0d, 0x00, 0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x03, 0x01, 0x07, 0x05, 0x0b, 0x09, 0x0f, 0x0d,
    0x00, 0x04, 0x08, 0x0c, 0x03, 0x07, 0x0b, 0x0f, 0x06, 0x02, 0x0e, 0x0a, 0x05, 0x01, 0x0d, 0x09, 0x00, 0x04, 0x08, 0x0c, 0x03, 0x07, 0x0b, 0x0f, 0x06, 0x02, 0x0e, 0x0a, 0x05, 0x01, 0x0d, 0x09,
    0x00, 0x08, 0x03, 0x0b, 0x06, 0x0e, 0x05, 0x0d, 0x0c, 0x04, 0x0f, 0x07, 0x0a, 0x02, 0x09, 0x01, 0x00, 0x08, 0x03, 0x0b, 0x06, 0x0e, 0x05, 0x0d, 0x0c, 0x04, 0x0f, 0x07, 0x0a, 0x02, 0x09, 0x01
};

//
// generate multiplication table for '4-bit' variable 'b'. Taken from OV paper!
//
static inline __m256i tbl32_gf16_multab2( uint8_t b ) {

    __m256i bx = _mm256_set1_epi16( b & 0xf );
    __m256i b1 = _mm256_srli_epi16( bx, 1 );

    const __m256i tab0 = _mm256_load_si256((__m256i const *) (__gf16_mulbase + 32 * 0));
    const __m256i tab1 = _mm256_load_si256((__m256i const *) (__gf16_mulbase + 32 * 1));
    const __m256i tab2 = _mm256_load_si256((__m256i const *) (__gf16_mulbase + 32 * 2));
    const __m256i tab3 = _mm256_load_si256((__m256i const *) (__gf16_mulbase + 32 * 3));

    __m256i mask_1  = _mm256_set1_epi16(1);
    __m256i mask_4  = _mm256_set1_epi16(4);
    __m256i mask_0  = _mm256_setzero_si256();

    return ( tab0 & _mm256_cmpgt_epi16( bx & mask_1, mask_0) )
           ^ ( tab1 & _mm256_cmpgt_epi16( b1 & mask_1, mask_0) )
           ^ ( tab2 & _mm256_cmpgt_epi16( bx & mask_4, mask_0) )
           ^ ( tab3 & _mm256_cmpgt_epi16( b1 & mask_4, mask_0) );
}

static inline __m256i linear_transform_8x8_256b( __m256i tab_l, __m256i tab_h, __m256i v, __m256i mask_f ) {
    return _mm256_shuffle_epi8(tab_l, v & mask_f)^_mm256_shuffle_epi8(tab_h, _mm256_srli_epi16(v, 4)&mask_f);
}

static inline __m256i gf16v_mul( __m256i a, uint8_t b ) {
    __m256i multab_l = tbl32_gf16_multab2( b );
    __m256i multab_h = _mm256_slli_epi16( multab_l, 4 );

    return linear_transform_8x8_256b( multab_l, multab_h, a, _mm256_set1_epi8(0xf) );
}

// GF(16) mul-by-{1,2,4,8} matrices in vgf2p8affineqb encoding
static const uint64_t mayo_gf16_gfni_base[4] = {
    0x0102040810204080ULL, 0x0809020480902040ULL,
    0x040c090240c09020ULL, 0x02060c092060c090ULL
};

// matrix for mul-by-a, composed from the base matrices (constant time)
static inline uint64_t mayo_gfni_tab(unsigned char a) {
    return (mayo_gf16_gfni_base[0] & (uint64_t) - (int64_t) (a & 1))
         ^ (mayo_gf16_gfni_base[1] & (uint64_t) - (int64_t) ((a >> 1) & 1))
         ^ (mayo_gf16_gfni_base[2] & (uint64_t) - (int64_t) ((a >> 2) & 1))
         ^ (mayo_gf16_gfni_base[3] & (uint64_t) - (int64_t) ((a >> 3) & 1));
}


#ifdef MAYO_GFNI
static const uint64_t MAYO_GF16_TAB[16] = {
    0x0000000000000000ULL, 0x0102040810204080ULL,
    0x0809020480902040ULL, 0x090b060c90b060c0ULL,
    0x040c090240c09020ULL, 0x050e0d0a50e0d0a0ULL,
    0x0c050b06c050b060ULL, 0x0d070f0ed070f0e0ULL,
    0x02060c092060c090ULL, 0x0304080130408010ULL,
    0x0a0f0e0da0f0e0d0ULL, 0x0b0d0a05b0d0a050ULL,
    0x060a050b60a050b0ULL, 0x0708010370801030ULL,
    0x0e03070fe03070f0ULL, 0x0f010307f0103070ULL,
};
 
static inline void mayo_gfni_tab32(__m256i a, uint64_t *out) {
    const __m512i T0 = _mm512_loadu_si512((const __m512i *) MAYO_GF16_TAB);
    const __m512i T1 = _mm512_loadu_si512((const __m512i *) (MAYO_GF16_TAB + 8));
 
    __m128i lo = _mm256_castsi256_si128(a);
    __m128i hi = _mm256_extracti128_si256(a, 1);
 
    // Zero-extend each element byte to a qword index.  vpermt2q reads only the
    // low 4 bits of each index, so any high-nibble junk in the input is ignored.
    __m512i i0 = _mm512_cvtepu8_epi64(lo);
    __m512i i1 = _mm512_cvtepu8_epi64(_mm_srli_si128(lo, 8));
    __m512i i2 = _mm512_cvtepu8_epi64(hi);
    __m512i i3 = _mm512_cvtepu8_epi64(_mm_srli_si128(hi, 8));
 
    _mm512_storeu_si512((__m512i *) (out +  0), _mm512_permutex2var_epi64(T0, i0, T1));
    _mm512_storeu_si512((__m512i *) (out +  8), _mm512_permutex2var_epi64(T0, i1, T1));
    _mm512_storeu_si512((__m512i *) (out + 16), _mm512_permutex2var_epi64(T0, i2, T1));
    _mm512_storeu_si512((__m512i *) (out + 24), _mm512_permutex2var_epi64(T0, i3, T1));
}

// out[i] = mayo_gfni_tab(in[i]), i < n. The batch bound is taken up front: written as
// "i + 32 <= n" the tail leaves i unbounded and gcc warns about the indexing.
static inline void mayo_gfni_tabs(const unsigned char *in, uint64_t *out, size_t n) {
    const size_t batched = n & ~(size_t) 31;
    for (size_t i = 0; i < batched; i += 32) {
        mayo_gfni_tab32(_mm256_loadu_si256((const __m256i *) (in + i)), out + i);
    }
    for (size_t i = batched; i < n; i++) {
        out[i] = mayo_gfni_tab(in[i]);
    }
}
#endif

#define O_AVX_ROUND_UP_ ((O_MAX + 1)/2*2)

static 
inline void mayo_O_multabs(const unsigned char *O, __m256i *O_multabs){
    // build multiplication tables 
    for (size_t r = 0; r < V_MAX; r++)
    {
        size_t c = 0;
        for (; c + 1  < O_MAX; c+=2)
        {
            O_multabs[O_AVX_ROUND_UP_/2*r + c/2] = tbl32_gf16_multab2(O[O_MAX*r + c]) ^ _mm256_slli_epi16(tbl32_gf16_multab2(O[O_MAX*r + c + 1]), 4);
        }
#if O_MAX % 2 == 1
        {
            O_multabs[O_AVX_ROUND_UP_/2*r + c/2] = tbl32_gf16_multab2(O[O_MAX*r + c]);
        }
#endif
    }
}


static 
inline void mayo_V_multabs(const unsigned char *V, __m256i *V_multabs){
    // build multiplication tables 
    size_t r;
    for (size_t c = 0; c < V_MAX; c++)
    {
        for (r = 0; r+1 < K_MAX; r+= 2)
        {
            V_multabs[K_OVER_2*c +  r/2] = tbl32_gf16_multab2(V[V_MAX*r + c]) ^ _mm256_slli_epi16(tbl32_gf16_multab2(V[V_MAX*(r+1) + c]), 4);
        }
#if K_MAX % 2 == 1
        V_multabs[K_OVER_2*c + r/2] = tbl32_gf16_multab2(V[V_MAX*r + c]);
#endif
    }
}

// Ox = sum_c x[c] * O[:,c]; OT is O transposed (V_MAX padded bytes per column).
// Shuffle-based, avoiding the scalar mul_f blocker.
#define MAYO_OT_STRIDE (((V_MAX + 31) / 32) * 32)

static
inline void mayo_Ot_rows_times_x(const unsigned char *OT, const unsigned char *x, unsigned char *Ox) {
    __m256i acc[MAYO_OT_STRIDE / 32];
    for (size_t j = 0; j < MAYO_OT_STRIDE / 32; j++) {
        acc[j] = _mm256_setzero_si256();
    }
    for (size_t c = 0; c < O_MAX; c++) {
        __m256i tab = tbl32_gf16_multab2(x[c]);
        for (size_t j = 0; j < MAYO_OT_STRIDE / 32; j++) {
            acc[j] ^= _mm256_shuffle_epi8(tab, _mm256_loadu_si256((const __m256i *)(OT + c * MAYO_OT_STRIDE + 32 * j)));
        }
    }
    for (size_t j = 0; j < MAYO_OT_STRIDE / 32; j++) {
        _mm256_storeu_si256((__m256i *)(Ox + 32 * j), acc[j]);
    }
}

static const unsigned char mayo_gf16_mul[512] __attribute__((aligned(32))) = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00, 
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07, 0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f, 
    0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07, 0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
    0x00,0x02,0x04,0x06,0x08,0x0a,0x0c,0x0e, 0x03,0x01,0x07,0x05,0x0b,0x09,0x0f,0x0d, 
    0x00,0x02,0x04,0x06,0x08,0x0a,0x0c,0x0e, 0x03,0x01,0x07,0x05,0x0b,0x09,0x0f,0x0d,
    0x00,0x03,0x06,0x05,0x0c,0x0f,0x0a,0x09, 0x0b,0x08,0x0d,0x0e,0x07,0x04,0x01,0x02, 
    0x00,0x03,0x06,0x05,0x0c,0x0f,0x0a,0x09, 0x0b,0x08,0x0d,0x0e,0x07,0x04,0x01,0x02,
    0x00,0x04,0x08,0x0c,0x03,0x07,0x0b,0x0f, 0x06,0x02,0x0e,0x0a,0x05,0x01,0x0d,0x09, 
    0x00,0x04,0x08,0x0c,0x03,0x07,0x0b,0x0f, 0x06,0x02,0x0e,0x0a,0x05,0x01,0x0d,0x09,
    0x00,0x05,0x0a,0x0f,0x07,0x02,0x0d,0x08, 0x0e,0x0b,0x04,0x01,0x09,0x0c,0x03,0x06, 
    0x00,0x05,0x0a,0x0f,0x07,0x02,0x0d,0x08, 0x0e,0x0b,0x04,0x01,0x09,0x0c,0x03,0x06,
    0x00,0x06,0x0c,0x0a,0x0b,0x0d,0x07,0x01, 0x05,0x03,0x09,0x0f,0x0e,0x08,0x02,0x04, 
    0x00,0x06,0x0c,0x0a,0x0b,0x0d,0x07,0x01, 0x05,0x03,0x09,0x0f,0x0e,0x08,0x02,0x04,
    0x00,0x07,0x0e,0x09,0x0f,0x08,0x01,0x06, 0x0d,0x0a,0x03,0x04,0x02,0x05,0x0c,0x0b, 
    0x00,0x07,0x0e,0x09,0x0f,0x08,0x01,0x06, 0x0d,0x0a,0x03,0x04,0x02,0x05,0x0c,0x0b,
    0x00,0x08,0x03,0x0b,0x06,0x0e,0x05,0x0d, 0x0c,0x04,0x0f,0x07,0x0a,0x02,0x09,0x01, 
    0x00,0x08,0x03,0x0b,0x06,0x0e,0x05,0x0d, 0x0c,0x04,0x0f,0x07,0x0a,0x02,0x09,0x01,
    0x00,0x09,0x01,0x08,0x02,0x0b,0x03,0x0a, 0x04,0x0d,0x05,0x0c,0x06,0x0f,0x07,0x0e, 
    0x00,0x09,0x01,0x08,0x02,0x0b,0x03,0x0a, 0x04,0x0d,0x05,0x0c,0x06,0x0f,0x07,0x0e,
    0x00,0x0a,0x07,0x0d,0x0e,0x04,0x09,0x03, 0x0f,0x05,0x08,0x02,0x01,0x0b,0x06,0x0c, 
    0x00,0x0a,0x07,0x0d,0x0e,0x04,0x09,0x03, 0x0f,0x05,0x08,0x02,0x01,0x0b,0x06,0x0c,
    0x00,0x0b,0x05,0x0e,0x0a,0x01,0x0f,0x04, 0x07,0x0c,0x02,0x09,0x0d,0x06,0x08,0x03, 
    0x00,0x0b,0x05,0x0e,0x0a,0x01,0x0f,0x04, 0x07,0x0c,0x02,0x09,0x0d,0x06,0x08,0x03,
    0x00,0x0c,0x0b,0x07,0x05,0x09,0x0e,0x02, 0x0a,0x06,0x01,0x0d,0x0f,0x03,0x04,0x08, 
    0x00,0x0c,0x0b,0x07,0x05,0x09,0x0e,0x02, 0x0a,0x06,0x01,0x0d,0x0f,0x03,0x04,0x08,
    0x00,0x0d,0x09,0x04,0x01,0x0c,0x08,0x05, 0x02,0x0f,0x0b,0x06,0x03,0x0e,0x0a,0x07, 
    0x00,0x0d,0x09,0x04,0x01,0x0c,0x08,0x05, 0x02,0x0f,0x0b,0x06,0x03,0x0e,0x0a,0x07,
    0x00,0x0e,0x0f,0x01,0x0d,0x03,0x02,0x0c, 0x09,0x07,0x06,0x08,0x04,0x0a,0x0b,0x05, 
    0x00,0x0e,0x0f,0x01,0x0d,0x03,0x02,0x0c, 0x09,0x07,0x06,0x08,0x04,0x0a,0x0b,0x05,
    0x00,0x0f,0x0d,0x02,0x09,0x06,0x04,0x0b, 0x01,0x0e,0x0c,0x03,0x08,0x07,0x05,0x0a, 
    0x00,0x0f,0x0d,0x02,0x09,0x06,0x04,0x0b, 0x01,0x0e,0x0c,0x03,0x08,0x07,0x05,0x0a};


static 
inline void mayo_S1_multabs(const unsigned char *S1, __m256i *S1_multabs) {
    size_t r;
    for (size_t c = 0; c < V_MAX; c++)
    {
        for (r = 0; r+1 < K_MAX; r+= 2)
        {
            S1_multabs[K_OVER_2*c +  r/2] = _mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S1[V_MAX*r + c])) 
                                          ^ _mm256_slli_epi16(_mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S1[V_MAX*(r+1) + c])), 4);
        }
#if K_MAX % 2 == 1
        S1_multabs[K_OVER_2*c +  r/2] = _mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S1[V_MAX*r + c]));
#endif
    }
}

static 
inline void mayo_S2_multabs(const unsigned char *S2, __m256i *S2_multabs) {
    // build multiplication tables 
    size_t r;
    for (size_t c = 0; c < O_MAX; c++)
    {
        for (r = 0; r+1 < K_MAX; r+= 2)
        {
            S2_multabs[K_OVER_2*c +  r/2] = _mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S2[O_MAX*r + c])) 
                                          ^ _mm256_slli_epi16(_mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S2[O_MAX*(r+1) + c])), 4);
        }
#if K_MAX % 2 == 1
        S2_multabs[K_OVER_2*c +  r/2] = _mm256_load_si256((__m256i *)(mayo_gf16_mul + 32*S2[O_MAX*r + c])) ;
#endif
    }
}

#endif

