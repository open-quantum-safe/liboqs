/**
 * @file reed_solomon.c
 * @brief Constant time implementation of Reed-Solomon codes
 */

#include "reed_solomon.h"
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include "crypto_memset.h"
#include "gf.h"
#include "parameters.h"
#ifdef VERBOSE
#include <stdbool.h>
#include <stdio.h>
#endif

/**
 * @brief Compiler helpers for constant-time routines.
 *
 * On GCC/Clang, CT_OPAQUE(x) makes the value of x opaque to the optimizer: the
 * compiler can no longer make assumptions about it, without actually reading or
 * writing it each time it is referenced. Other compilers fall back to volatile.
 * This only constrains the optimizer; it is not a memory fence.
 */
#if defined(__GNUC__) || defined(__clang__)
#define CT_VOLATILE
#define CT_OPAQUE(var) __asm__("" : "+r"(var) : /* no inputs */)
#else
#define CT_VOLATILE volatile
#define CT_OPAQUE(var)
#endif

/**
 * @def GF_LANES
 * @brief Number of GF(2^8) values per AVX2 vector: 16 lanes of 16 bits.
 */
#define GF_LANES 16

/**
 * @def SYND_VEC_COUNT
 * @brief Number of AVX2 vectors needed to hold the 2·PARAM_T syndromes.
 *
 * Rounds the syndrome count (2·PARAM_T) up to the next multiple of \c GF_LANES.
 */
#define SYND_VEC_COUNT (CEIL_DIVIDE(2 * PARAM_T, GF_LANES))

/**
 * @def POSITIONS_BLOCKS
 * @brief Number of \c GF_LANES-wide blocks needed to cover all message positions.
 *
 * This macro rounds up the number of message bytes \c PARAM_K to the next
 * multiple of \c GF_LANES, matching the lane width used by AVX2 vectors.
 * It is used to iterate over message positions in fixed-size SIMD blocks
 * during Chien search / polynomial evaluation.
 */
#define POSITIONS_BLOCKS ((PARAM_K + GF_LANES - 1) / GF_LANES)

static inline uint16_t mod(uint16_t i, uint16_t modulus);
static inline uint16_t make_nonzero_mask(uint16_t x);
static inline uint8_t is_zero(uint8_t x);
static inline void compute_syndromes(__m256i *syndrome_vecs, const uint8_t *cdw);
static inline void compute_error_locator_polynomial(uint16_t *sigma, const uint16_t *syndromes);
static inline void compute_error_positions(uint8_t *error_positions, const uint16_t *sigma);
static inline void evaluate_poly_at_all_msg_points(uint8_t *out, const uint16_t *poly);
static inline void batch_inverse(uint8_t *inv, const uint8_t *a);
static inline void correct_errors(uint8_t *message, const uint8_t *cdw_bytes, const uint16_t *syndromes,
                                  const uint16_t *sigma, const uint8_t *error_positions);

/**
 * @brief Precomputed AVX2 table of \f$\alpha_i^j\f$ powers for syndrome accumulation (part 1/4).
 *
 * Each entry is one 256-bit block used by compute_syndromes() for a fixed
 * codeword position. The 16-bit lanes contain the GF(2^8) powers needed for
 * one contiguous block of syndrome indices.
 *
 * The table has \c PARAM_N1 - 1 entries, one for each non-constant codeword
 * coefficient processed during syndrome accumulation.
 */
static const __m256i alpha_ij_vecs_1[89] = {
    {0x0011000f00050003, 0x001a00ff00550033, 0x00a100960072002e, 0x005f0035001300f8},
    {0x001a005500110005, 0x005f001300a10072, 0x00f7009500d80038, 0x00e50066001e0006},
    {0x00a1002e0055000f, 0x00f7007300380035, 0x003700340066000a, 0x005300ab00d90026},
    {0x005f00a1001a0011, 0x00e5001e00f700d8, 0x00530090006a0037, 0x004c00d3004f0014},
    {0x00d8003500720033, 0x006a00e400660002, 0x00d300cc000400ab, 0x00830008004d00d4},
    {0x00f7003800a10055, 0x005300d900370066, 0x0062006700d30044, 0x00b500b3006b0078},
    {0x001e0073001300ff, 0x004f00f500d900e4, 0x006b0028004d00cd, 0x00fe001d005700ce},
    {0x00e500f7005f001a, 0x004c004f0053006a, 0x00b5008100830062, 0x00fb002f00fe000b},
    {0x0037000a0038002e, 0x006200cd004400ab, 0x00bb00f900b3009e, 0x00c300c200600092},
    {0x006a006600d80072, 0x0083004d00d30004, 0x002f0061001000b3, 0x009f004000fa003a},
    {0x0090003400950096, 0x00810028006700cc, 0x00d20071006100f9, 0x009b00ef002c0041},
    {0x0053003700f700a1, 0x00b5006b006200d3, 0x00c300d2002f00bb, 0x00fc00e80082009c},
    {0x00140026000600f8, 0x000b00ce007800d4, 0x009c0041003a0092, 0x004500630065009d},
    {0x004f00d9001e0013, 0x00fe0057006b004d, 0x0082002c00fa0060, 0x0012004a00a50065},
    {0x00d300ab00660035, 0x002f001d00b30008, 0x00e800ef004000c2, 0x00390036004a0063},
    {0x004c005300e5005f, 0x00fb00fe00b50083, 0x00fc009b009f00c3, 0x0003003900120045},
    {0x00e0000c005c00e1, 0x005d00ec005000bd, 0x00b000b100bc00ed, 0x00e10001000d0051},
    {0x0062004400370038, 0x00c3006000bb00b3, 0x00a8000700e800d5, 0x0034003500c70085},
    {0x001800d100eb0048, 0x005b006d002b009a, 0x002900cf00c500df, 0x00f50066009600fd},
    {0x008300d3006a00d8, 0x009f00fa002f0010, 0x003900c6001b00e8, 0x00d400ab00020033},
    {0x006b00cd00d90073, 0x0082003d0060001d, 0x00c7008c004a0043, 0x009e00d300260038},
    {0x0081006700900095, 0x009b002c00d20061, 0x002e00dd00c60007, 0x00c40008003c00aa},
    {0x0049003b00e600a4, 0x00ea00ba0032007d, 0x00730052008d00ca, 0x001900b300a90090},
    {0x00b50062005300f7, 0x00fc008200c3002f, 0x0034002e003900a8, 0x0016001d009e00d1},
    {0x0010000800040002, 0x001b008000400020, 0x00ab00d8006c0036, 0x005e002f009a004d},
    {0x000b007800140006, 0x00450065009c003a, 0x00d100aa00330085, 0x00ba00c200d600d0},
    {0x00bb009e0044000a, 0x00a8004300d500c2, 0x003b00d90035007c, 0x00b6004000ae00b5},
    {0x00fe006b004f001e, 0x001200a5008200fa, 0x009e003c000200c7, 0x001f00ef00e700d6},
    {0x0087007f00680022, 0x008f00990089005e, 0x00db004c00e40055, 0x00cf00e800c00093},
    {0x002f00b300d30066, 0x0039004a00e80040, 0x001d000800ab0035, 0x0036006300ef00c2},
    {0x00e900db00b200aa, 0x001c00e3006f0074, 0x009200dc00cc00f7, 0x004b004a00580047},
    {0x00fb00b5004c00e5, 0x0003001200fc009f, 0x001600c400d40034, 0x00050036001f00ba},
    {0x00d200f900670034, 0x002e008c000700ef, 0x001500bb000800d9, 0x0038003900ca0089},
    {0x005d005000e0005c, 0x00e1000d00b000bc, 0x00ed00ec00bd000c, 0x005c0001005100b1},
    {0x00fa001d004d00e4, 0x00020097004a0080, 0x00ef003a009a00d3, 0x000400350094001b},
    {0x00c300bb00620037, 0x003400c700a800e8, 0x00b60015001d003b, 0x006700660024008b},
    {0x004700a300f10059, 0x00be001100f30025, 0x0043005b007d0078, 0x00b900ab001a005a},
    {0x005b002b001800eb, 0x00f50096002900c5, 0x002d00640020007f, 0x005700d300950017},
    {0x009c009200780026, 0x00d1003800850063, 0x008b008900c200b5, 0x002b0008003700c7},
    {0x009f002f0083006a, 0x00d400020039001b, 0x00360025005e001d, 0x003a00b300040072},
    {0x00ac00ae00b900be, 0x00a600e500a200cb, 0x00f200a50074002b, 0x00e2001d004c00a4},
    {0x00820060006b00d9, 0x009e002600c7004a, 0x002400ca00ef00ae, 0x00d5002f00780037},
    {0x007a001600dc0070, 0x009800e6000f0091, 0x0055003e008000d2, 0x00c100c2004900f5},
    {0x009b00d200810090, 0x00c4003c002e00c6, 0x0038007b00250015, 0x00210040002700b2},
    {0x00e800c200b300ab, 0x001d00d300350036, 0x0066003900630040, 0x004a00ef002f0008},
    {0x00ea0032004900e6, 0x001900a90073008d, 0x00d900b400cb0075, 0x005a00e800b70081},
    {0x00c8001500760031, 0x007100f1000a0094, 0x004400ff00910082, 0x00dd006300470030},
    {0x00fc00c300b50053, 0x0016009e00340039, 0x00670038003600b6, 0x000f004a00d5002b},
    {0x00a5003d005700f5, 0x00e7008100260097, 0x007800220094006f, 0x00480036009b00a0},
    {0x001b004000100004, 0x005e009a00ab006c, 0x00b3006a00970063, 0x00e4003900c500fa},
    {0x00b000ed0050000c, 0x00ed0050000c0001, 0x0050000c000100b0, 0x000c000100b000ed},
    {0x0045009c000b0014, 0x00ba00d600d10033, 0x002b00b20072008b, 0x00a90035003e002a},
    {0x007900750027003c, 0x009d008700cd0072, 0x006000a600d800f3, 0x00d00066008f0058},
    {0x00a800d500bb0044, 0x00b600ae003b0035, 0x0032006b0066008c, 0x00f900ab00a200fc},
    {0x00c600ef006100cc, 0x0025003a000800d8, 0x0040009a006a0039, 0x007d00d3003300cb},
    {0x0012008200fe004f, 0x001f00e7009e0002, 0x00d5002700040024, 0x004e00080048003e},
    {0x002900df002b00d1, 0x002d00c3007f0066, 0x0089009200d3000f, 0x003d00b30034008c},
    {0x008f008900870068, 0x00cf00c000db00e4, 0x006f00fb004d00a1, 0x0064001d00310084},
    {0x00a700b600ad00b8, 0x00e300da00f9006a, 0x0007005600830073, 0x0058002f006e0005},
    {0x003900e8002f00d3, 0x003600ef001d00ab, 0x004a004000b30066, 0x006300c200080035},
    {0x008400af0093006e, 0x008a007a00a30004, 0x00f300ba00100026, 0x00de00400098001e},
    {0x001c006f00e900b2, 0x004b0058009200cc, 0x0085007a00610053, 0x00ee00ef00f000be},
    {0x00c70043006000cd, 0x0024006f00ae00d3, 0x00a200af002f00d1, 0x007c00e800920044},
    {0x000300fc00fb004c, 0x0005001f001600d4, 0x000f0021003a0067, 0x00110063004e00a9},
    {0x00330063003a00d4, 0x0072001b00c2004d, 0x003500cb00fa0008, 0x00d8004a005e0083},
    {0x002e000700d20067, 0x003800ca00150008, 0x000a00a80040006b, 0x00370036007500db},
    {0x00f8002d00b700a9, 0x00060086003d0083, 0x002600ee009f00db, 0x00140039008e0027},
    {0x00e100b0005d00e0, 0x005c005100ed00bd, 0x000c000d00bc0050, 0x00e0000100b100ec},
    {0x007300ca0032003b, 0x00d90029007500b3, 0x00cd002400e800a3, 0x006b0035002d00d2},
    {0x0002004a00fa004d, 0x0004009400ef009a, 0x0008003300c5002f, 0x001000660091005e},
    {0x0022008b003f00d7, 0x006800dd00df0010, 0x007f005f001b0016, 0x008700ab007b00da},
    {0x003400a800c30062, 0x0067002400b6001d, 0x00f9000a004a0032, 0x00d200d3007c00df},
    {0x0059004200e200a6, 0x00f1000300af0061, 0x00a300eb00c6003d, 0x00470008000500ea},
    {0x00be00f3004700f1, 0x00b9001a0043007d, 0x00ae00f5008d009c, 0x00ac00b3005f00f4},
    {0x00ab003600400008, 0x00b300350063002f, 0x00c200d3003900ef, 0x00e8001d0066004a},
    {0x00f50029005b0018, 0x00570095002d0020, 0x003d00d7006c0089, 0x00a5002f0090000e},
    {0x003c008c002c0028, 0x0027002200ca003a, 0x007500b9003300af, 0x007900c2006800a7},
    {0x00d10085009c0078, 0x002b0037008b00c2, 0x00df00db003500fc, 0x0029004000620024},
    {0x006e00f200da0088, 0x00930070004200fa, 0x00af000b0002002d, 0x008400ef00dc00ff},
    {0x00d40039009f0083, 0x003a00040036005e, 0x0063007d00e4004a, 0x003300e8001000d8},
    {0x003b007c00d5009e, 0x003200d1008c0040, 0x00ca006000ab0042, 0x00730063002b0034},
    {0x00a600a200ac00b9, 0x00e2004c00f20074, 0x004200e700cc0029, 0x0059004a00fb00e6},
    {0x00280024002a00d0, 0x002c00d7007c009f, 0x008c004700d400f2, 0x003c0036003f00b8},
    {0x009e00c70082006b, 0x00d50078002400ef, 0x007c0075000800a2, 0x003b0039009c0062},
    {0x00bd000100bc00bd, 0x00bc00bd000100bc, 0x000100bc00bd0001, 0x00bd000100bc00bd},
    {0x0098000f007a00dc, 0x00c1004900550080, 0x00a10023009a002e, 0x0030003500ea0057},
    {0x00db00550089007f, 0x006f00f900a100e8, 0x00f700fc001d0038, 0x00920066000700a3},
    {0x00c4002e009b0081, 0x0021002700380025, 0x00370099007d000a, 0x006d00ab007900e9},
    {0x003000a100c10098, 0x0077001900f700c5, 0x0053008600200037, 0x00c900d3005a00e7},
};

/**
 * @brief Precomputed AVX2 table of \f$\alpha_i^j\f$ powers for syndrome accumulation (part 2/4).
 *
 * Each entry is one 256-bit block used by compute_syndromes() for a fixed
 * codeword position. The 16-bit lanes contain the GF(2^8) powers needed for
 * one contiguous block of syndrome indices.
 *
 * The table has \c PARAM_N1 - 1 entries, one for each non-constant codeword
 * coefficient processed during syndrome accumulation.
 */
static const __m256i alpha_ij_vecs_2[89] = {
    {0x00d80048003800e1, 0x00f700a400950073, 0x001e000a00060002, 0x00e500aa00660022},
    {0x006a00eb0037005c, 0x005300e6009000d9, 0x004f004400140004, 0x004c00b200d30068},
    {0x00d300d10044000c, 0x0062003b006700cd, 0x006b009e00780008, 0x00b500db00b3007f},
    {0x00830018006200e0, 0x00b500490081006b, 0x00fe00bb000b0010, 0x00fb00e9002f0087},
    {0x0010009a00b300bd, 0x002f007d0061001d, 0x00fa00c2003a0020, 0x009f00740040005e},
    {0x002f002b00bb0050, 0x00c3003200d20060, 0x008200d5009c0040, 0x00fc006f00e80089},
    {0x00fa006d006000ec, 0x008200ba002c003d, 0x00a5004300650080, 0x001200e3004a0099},
    {0x009f005b00c3005d, 0x00fc00ea009b0082, 0x001200a80045001b, 0x0003001c0039008f},
    {0x00e800df00d500ed, 0x00a800ca00070043, 0x00c7007c00850036, 0x003400f700350055},
    {0x001b00c500e800bc, 0x0039008d00c6004a, 0x000200350033006c, 0x00d400cc00ab00e4},
    {0x00c600cf000700b1, 0x002e005200dd008c, 0x003c00d900aa00d8, 0x00c400dc0008004c},
    {0x0039002900a800b0, 0x00340073002e00c7, 0x009e003b00d100ab, 0x00160092001d00db},
    {0x003300fd00850051, 0x00d1009000aa0038, 0x00d600b500d0004d, 0x00ba004700c20093},
    {0x0002009600c7000d, 0x009e00a9003c0026, 0x00e700ae00d6009a, 0x001f005800ef00c0},
    {0x00ab006600350001, 0x001d00b3000800d3, 0x00ef004000c2002f, 0x0036004a006300e8},
    {0x00d400f5003400e1, 0x0016001900c4009e, 0x001f00b600ba005e, 0x0005004b003600cf},
    {0x00bd00e0000c005c, 0x00ed005d00ec0050, 0x005100b000b100bc, 0x005c00e10001000d},
    {0x001d007f003b000c, 0x00b60075001500ae, 0x0024008c008b0063, 0x00670053006600a1},
    {0x00200027007f00e0, 0x002d0065006400c3, 0x0095000f001700c6, 0x0057008800d300be},
    {0x005e0020001d00bd, 0x003600cb002500ef, 0x0004006600720097, 0x003a006100b3004d},
    {0x00ef00c300ae0050, 0x0024002900ca006f, 0x007800d100370035, 0x00d50015002f00f9},
    {0x00250064001500ec, 0x003800b4007b00ca, 0x0027006b00b2006a, 0x0021007a004000fb},
    {0x00cb00650075005d, 0x00d9004800b40029, 0x00b700a3008100d4, 0x005a009900e800bf},
    {0x0036002d00b600ed, 0x006700d900380024, 0x00d50032002b00b3, 0x000f0085004a006f},
    {0x009700c6006300bc, 0x00b300d4006a0035, 0x00c500ef00fa007d, 0x00e4007200390091},
    {0x00720017008b00b1, 0x002b008100b20037, 0x003e00fc002a00fa, 0x00a900be00350084},
    {0x0066000f008c00b0, 0x003200a3006b00d1, 0x00a2004200fc00ef, 0x00f9006200ab0038},
    {0x0004009500240051, 0x00d500b700270078, 0x004800a2003e00c5, 0x004e00f000080031},
    {0x004d00be00a1000d, 0x006f00bf00fb00f9, 0x0031003800840091, 0x006400b7001d0018},
    {0x00b300d300660001, 0x004a00e80040002f, 0x000800ab00350039, 0x006300ef00c2001d},
    {0x00610088005300e1, 0x00850099007a0015, 0x00f0006200be0072, 0x00ee00a500ef00b7},
    {0x003a00570067005c, 0x000f005a002100d5, 0x004e00f900a900e4, 0x001100ee00630064},
    {0x00400092006b000c, 0x000a002400a800af, 0x0075006000db00d3, 0x0037000f003600fc},
    {0x00bc005d005000e0, 0x000c00e1000d00b0, 0x00b100ed00ec00bd, 0x00e0005c00010051},
    {0x00c50074002f00bd, 0x0008006a00330036, 0x009100e8005e0061, 0x001000d40066006c},
    {0x004a008900320050, 0x00f900cd000a00a2, 0x007c00ca00df00c2, 0x00d200b500d300f7},
    {0x008d001f009c00ec, 0x00ae00dc00f500a1, 0x005f008500f4009f, 0x00ac00a000b3003c},
    {0x006c00790089005d, 0x003d00d600d70034, 0x00900055000e0025, 0x00a500da002f00b9},
    {0x0035008c00fc00ed, 0x00df00d200db0044, 0x006200340024004a, 0x00290043004000a3},
    {0x00e4006c004a00bc, 0x00630074007d0008, 0x001000d300d80094, 0x003300c600e800fa},
    {0x00cc0013002900b1, 0x004200c100e700b5, 0x00fb007f00e60033, 0x005900b4004a009d},
    {0x0008003400a200b0, 0x007c002d00750092, 0x009c002b00620066, 0x003b000a00390007},
    {0x009a0014002e0051, 0x00a1001200230032, 0x00ea0015005700cc, 0x00300068003500ee},
    {0x007d00d7000a000d, 0x003700fd00990075, 0x0079008200e90083, 0x006d009800ab0003},
    {0x00c200b300ab0001, 0x00d30035003600e8, 0x003900630040001d, 0x00ef002f00080066},
    {0x007400d600cd00e1, 0x006b00eb00fd002d, 0x00f800f3009b003a, 0x00f400c0001d00b8},
    {0x008000fb009e005c, 0x00bb006e001300f3, 0x00be002400770074, 0x007b006500c20081},
    {0x0063003d00f9000c, 0x00d2006b0037007c, 0x003b0073002900e8, 0x0055008b00ef0092},
    {0x0091002a009200e0, 0x009c00690068002e, 0x00c4005300f600cb, 0x00eb0084006300e2},
    {0x0094002500c200bd, 0x00e8003a00830066, 0x002000080002008d, 0x004d00d800360080},
    {0x000100b000ed0050, 0x00b000ed0050000c, 0x00ed0050000c0001, 0x0050000c000100b0},
    {0x00d8000e00df00ec, 0x0029009b00e90062, 0x0023001600280002, 0x00b700b90066008a},
    {0x006a00dd0043005d, 0x00c7000900e200db, 0x00cf009c00f00004, 0x002a001900d300ff},
    {0x00d3005500ca00ed, 0x007300f30082002b, 0x00f200af00160008, 0x000700c300b30037},
    {0x00830002003600bc, 0x00ab009700c500c2, 0x0072004a00740010, 0x008d0080002f00d4},
    {0x00100090007c00b1, 0x003b00f80079009c, 0x00eb00f200230020, 0x00ff004600400076},
    {0x002f00cd005500b0, 0x00db0037008500b6, 0x0067002e00ca0040, 0x002600f200e800ae},
    {0x00fa00b900f70051, 0x009200b800030007, 0x00760037008a0080, 0x00d700f8004a005b},
    {0x009f003000d9000d, 0x001500b900a40042, 0x009300cd0011001b, 0x00f0009000390023},
    {0x00e8002f00d30001, 0x00ef001d00ab0039, 0x004000b300660036, 0x00c200080035004a},
    {0x001b0056007800e1, 0x004300fb00a90055, 0x00c10092004f006c, 0x007e002700ab0017},
    {0x00c600da00b5005c, 0x008b00c00098000a, 0x004600c300b900d8, 0x000900e7000800f8},
    {0x003900b6002b000c, 0x00f2008900a30053, 0x008500df00bb00ab, 0x008c0082001d00d9},
    {0x003300a500d200e0, 0x005500f4006d003b, 0x00ff000700b7004d, 0x001a000900c200d7},
    {0x00020091004000bd, 0x006600c6007400b3, 0x00e40036009f009a, 0x006a008d00ef0010},
    {0x00ab008500820050, 0x0044007c00b600a3, 0x00cd00c7006f002f, 0x0062005500630016},
    {0x00d40052006f00ec, 0x00780096000900d2, 0x00ce00f70079005e, 0x000b0059003600da},
    {0x00bd00e100b0005d, 0x0050005c005100ed, 0x00ec000c000d00bc, 0x005d00e0000100b1},
    {0x001d003700f300ed, 0x006000d1007c0089, 0x003d0078002e0063, 0x008200f9006600a8},
    {0x002000cc003900bc, 0x0040008300720063, 0x0080001d00e400c6, 0x001b003a00d30097},
    {0x005e00f1000f00b1, 0x008900f000e500a8, 0x009900d2006e0097, 0x008f00ba00b30048},
    {0x00ef00db007300b0, 0x00070060004400f2, 0x008c0075007f0035, 0x002e00fc002f0053},
    {0x002500fe00260051, 0x00f300c90018000f, 0x0011006f0019006a, 0x00be000e00400028},
    {0x00cb004e00d1000d, 0x00a2007a005700f7, 0x00e5008b005600d4, 0x00a600f600e80027},
    {0x0036004000080001, 0x00350063002f00ab, 0x00d3003900ef00b3, 0x001d0066004a00c2},
    {0x0097009d00db00e1, 0x0026003e003f0067, 0x008100a10054007d, 0x00e7006e003900ac},
    {0x007200c800a3005c, 0x00cd004b00ac007f, 0x0087002600e300fa, 0x009d00490035001f},
    {0x006600ca0016000c, 0x007f002e006f00bb, 0x00c30067007c00ef, 0x002d00ae00ab00f3},
    {0x0004005a003d00e0, 0x00a300e500450016, 0x007a00db001300c5, 0x008a002c000800b4},
    {0x004d009700ef00bd, 0x00c200cc008d0040, 0x001b002f006a0091, 0x00720025001d0002},
    {0x00b3002e00af0050, 0x0075007800c700df, 0x0029003d00670039, 0x00d900a800c20044},
    {0x0061001e002d00ec, 0x00af0030004800fc, 0x0003008900490072, 0x00f100fd00ef00d0},
    {0x003a00310042005d, 0x00ca00e900be008b, 0x0022002d00ad00e4, 0x002700a4006300fe},
    {0x0040006700f200ed, 0x008c003d00cd0085, 0x00d1002900c300d3, 0x0032004400360015},
    {0x00bc00bd000100bc, 0x000100bc00bd0001, 0x00bd000100bc00bd, 0x00bc00bd000100bc},
    {0x00c5000b003800b1, 0x00f7001f00690073, 0x0019000a00a50061, 0x0077008700660009},
    {0x004a00ae003700b0, 0x005300a8001600d9, 0x0015004400f300c2, 0x0085003d00d30029},
    {0x008d003f00440051, 0x0062001700c000cd, 0x009d009e001c009f, 0x009600c100b30005},
    {0x006c00ba0062000d, 0x00b500ff008e006b, 0x00f400bb00480025, 0x007000cf002f00aa},
};

/**
 * @brief Precomputed AVX2 table of \f$\alpha_i^j\f$ powers for syndrome accumulation (part 3/4).
 *
 * Each entry is one 256-bit block used by compute_syndromes() for a fixed
 * codeword position. The 16-bit lanes contain the GF(2^8) powers needed for
 * one contiguous block of syndrome indices.
 *
 * The table has \c PARAM_N1 - 1 entries, one for each non-constant codeword
 * coefficient processed during syndrome accumulation.
 */
static const __m256i alpha_ij_vecs_3[89] = {
    {0x003700e4005c0034, 0x006a002600eb0059, 0x0090007000d900be, 0x0053003100e600ab},
    {0x0062004d00e00067, 0x00830078001800f1, 0x008100dc006b00b9, 0x00b50076004900b3},
    {0x00bb001d005000f9, 0x002f0092002b00a3, 0x00d20016006000ae, 0x00c30015003200c2},
    {0x00c300fa005d00d2, 0x009f009c005b0047, 0x009b007a008200ac, 0x00fc00c800ea00e8},
    {0x00e8008000bc00ef, 0x001b006300c50025, 0x00c60091004a00cb, 0x00390094008d0036},
    {0x00a8004a00b00007, 0x00390085002900f3, 0x002e000f00c700a2, 0x0034000a00730035},
    {0x00c70097000d008c, 0x0002003800960011, 0x003c00e6002600e5, 0x009e00f100a900d3},
    {0x0034000200e1002e, 0x00d400d100f500be, 0x00c40098009e00a6, 0x001600710019001d},
    {0x003b00d3000c00d9, 0x001d00b5007f0078, 0x001500d200ae002b, 0x00b6008200750040},
    {0x001d009a00bd0008, 0x005e00c20020007d, 0x0025008000ef0074, 0x0036009100cb0063},
    {0x0015003a00ec00bb, 0x002500890064005b, 0x007b003e00ca00a5, 0x003800ff00b40039},
    {0x00b600ef00ed0015, 0x0036008b002d0043, 0x00380055002400f2, 0x0067004400d90066},
    {0x008b001b00b10089, 0x007200c70017005a, 0x00b200f5003700a4, 0x002b003000810008},
    {0x00240094005100ca, 0x000400370095001a, 0x002700490078004c, 0x00d5004700b7002f},
    {0x0066003500010039, 0x00b3000800d300ab, 0x004000c2002f001d, 0x004a006300e800ef},
    {0x00670004005c0038, 0x003a002b005700b9, 0x002100c100d500e2, 0x000f00dd005a004a},
    {0x005000bd00e0000c, 0x00bc00ed005d00ec, 0x000d005100b000b1, 0x000c005c00e10001},
    {0x0032002f0050006b, 0x004a00fc0089009c, 0x000a002e00a20029, 0x00f9009e00cd00ab},
    {0x00890074005d0092, 0x006c008c0079001f, 0x00d7001400340013, 0x003d00fb00d600b3},
    {0x004a00c500bc0040, 0x00e40035006c008d, 0x007d009a000800cc, 0x00630080007400c2},
    {0x00a2003600b000af, 0x00080044003400a1, 0x00750032009200b5, 0x007c00f3002d00e8},
    {0x000a0033000d00a8, 0x007d00db00d700f5, 0x00990023007500e7, 0x0037001300fd0036},
    {0x00cd006a00e10024, 0x007400d200d600dc, 0x00fd0012002d00c1, 0x006b006e00eb0035},
    {0x00f90008000c000a, 0x006300df003d00ae, 0x003700a1007c0042, 0x00d200bb006b00d3},
    {0x00c2006100bd00d3, 0x0094004a0025009f, 0x008300cc00660033, 0x00e80074003a001d},
    {0x00df005e00ec00db, 0x00d80024000e00f4, 0x00e90057006200e6, 0x00290077009b0040},
    {0x00ca00e800ed0060, 0x00d3003400550085, 0x00820015002b007f, 0x0073002400f30063},
    {0x007c009100b10075, 0x001000620090005f, 0x007900ea009c00fb, 0x003b00be00f80039},
    {0x00f7006c005100fc, 0x00fa00a300b9003c, 0x000300ee0007009d, 0x0092008100b80066},
    {0x00d3006600010036, 0x00e80040002f00b3, 0x00ab00350039004a, 0x00ef00c2001d0008},
    {0x00b500d4005c000f, 0x00c6004300da00a0, 0x00980068000a00b4, 0x008b006500c0002f},
    {0x00d2001000e00037, 0x0033002900a500ac, 0x006d0030003b0059, 0x0055007b00f400ef},
    {0x008200c20050003b, 0x00ab00a10085002d, 0x00b600c300a30078, 0x00440073007c004a},
    {0x00b000bc005d0050, 0x00bd000c00e1000d, 0x005100b100ed00ec, 0x005000e0005c0001},
    {0x003900cb00bc00c2, 0x002000b300cc00d8, 0x0072008d0063009f, 0x0040007d008300ab},
    {0x0073003900b00082, 0x00ef001600db00d1, 0x0044003800f2002d, 0x000700d5006000b3},
    {0x00d100d8000d002d, 0x00cb0082004e0076, 0x0057006e00f700dd, 0x00a200cf007a00c2},
    {0x00db00cc00e10085, 0x009700ca009d004e, 0x003f000b0067001e, 0x00260003003e00e8},
    {0x001600b3000c00a1, 0x006600a200ca0082, 0x006f003d00bb003b, 0x007f0053002e0036},
    {0x00ef002000bd00ab, 0x004d0066009700cb, 0x008d00c500400061, 0x00c2009a00cc0035},
    {0x002d009f00ec0078, 0x0061003b001e00dd, 0x0048008a00fc00c0, 0x00af003f003000d3},
    {0x00f2006300ed00a3, 0x004000bb006700f7, 0x00cd0073008500fc, 0x008c0043003d001d},
    {0x0038008d00b100c3, 0x00c5003d000b006e, 0x0069004c0073008a, 0x00f700a7001f0040},
    {0x00440072005100b6, 0x008d006f003f0057, 0x00c0006900cd0048, 0x0062001e00170063},
    {0x00b300ab0001004a, 0x0035003600e800c2, 0x00630040001d00d3, 0x002f000800660039},
    {0x00600083005c007c, 0x00cc002e003e007a, 0x0017001f003d0030, 0x0082009300180066},
    {0x00d5007d00e00073, 0x009a0053000300cf, 0x001e00a70043003f, 0x00a8009d00930008},
    {0x0007004000500044, 0x00c2007f002600a2, 0x006200f7008c00af, 0x002e00a80082002f},
    {0x00850025005d007f, 0x008000600028001e, 0x008700a900380012, 0x00d1001a008600ef},
    {0x003500c600bc002f, 0x009100ef007d00d4, 0x009f006100d30072, 0x001d00cc0033004a},
    {0x000c000100b000ed, 0x000100b000ed0050, 0x00b000ed0050000c, 0x00ed0050000c0001},
    {0x007f00e4000d006f, 0x006a007c00540056, 0x001c00a500c30049, 0x002d00c900c400ab},
    {0x00ae004d00e10042, 0x0083000a007b009b, 0x00590017006f006d, 0x002400a5004100b3},
    {0x0075001d000c00c7, 0x002f006700a1008b, 0x009e000a00290089, 0x00d9007c004300c2},
    {0x006300fa00bd0066, 0x009f001d0004006c, 0x0020004d00350091, 0x00b300e4009400e8},
    {0x008c008000ec00cd, 0x001b00c3008100e5, 0x009d001900d10003, 0x003200b900060036},
    {0x00a1004a00ed00b5, 0x003900af0060003b, 0x008b009c00f900d9, 0x006f001600620035},
    {0x0053009700b10016, 0x000200f300ac0027, 0x00050009001500d0, 0x0085009b00ad00d3},
    {0x006b0002005100d5, 0x00d4005500770041, 0x00e600dd00af00e9, 0x000a000e00ac001d},
    {0x002f00d300010063, 0x001d00ab003900e8, 0x00b30066003600ef, 0x00080035004a0040},
    {0x009c009a005c0029, 0x005e006b00a400e3, 0x00b700a600a10046, 0x00ae00b200030063},
    {0x00fc003a00e00055, 0x002500ae006e00f6, 0x00c10087004400fd, 0x00df00d600310039},
    {0x002900ef00500026, 0x003600d500f90037, 0x00f3007500b50034, 0x0042009c00db0066},
    {0x002e001b005d0062, 0x0072002d00e700a6, 0x00960077003200f1, 0x00a1009900560008},
    {0x00ab009400bc001d, 0x0004003900800061, 0x00cc009700e8007d, 0x00d3006c0025002f},
    {0x009e003500b00032, 0x00b300f7008b003d, 0x00f9003400f3009c, 0x00bb00d9008c00ef},
    {0x00920004000d00df, 0x003a00cd00b400ea, 0x00410018002e00f4, 0x009c00980095004a},
    {0x00ed00bd00e100b0, 0x00bc0050005c0051, 0x00b100ec000c000d, 0x00b0005d00e00001},
    {0x0043002f000c00f2, 0x004a00150062000f, 0x008c00d500db00f7, 0x00c700af002b00ab},
    {0x0036007400bd0035, 0x006c00e80061006a, 0x00d800cb00c200d4, 0x00ab008d009f00b3},
    {0x005500c500ec0053, 0x00e4004200470028, 0x004c001c00b60027, 0x00db0095004600c2},
    {0x00d9003600ed009e, 0x0008000f006f002b, 0x00bb00370042003d, 0x0015003b00c700e8},
    {0x0078003300b1002b, 0x007d00d9001200c0, 0x005b0088005500c8, 0x0043008700700036},
    {0x002b006a0051003d, 0x0074009e00ff00c8, 0x00a500930053007b, 0x00f2006400980035},
    {0x00400008000100e8, 0x0063002f00ab0036, 0x003900ef00b30035, 0x0066004a00c200d3},
    {0x006f0061005c008b, 0x0094007500d000ff, 0x0022004500d2004f, 0x007800050023001d},
    {0x00f3005e00e000a2, 0x00d8000700710090, 0x00a600b4008900c4, 0x006000f500ee0040},
    {0x000f00e8005000f7, 0x00d300f20075009e, 0x0092002600a80032, 0x008900b500380063},
    {0x00260091005d00d1, 0x0010007300f400ad, 0x00ba00b9000f0058, 0x00f30041004c0039},
    {0x0008006c00bc00b3, 0x00fa00d300940074, 0x00cb002000ab00c6, 0x003500c500610066},
    {0x00a3006600b000ae, 0x00e800f9003800fc, 0x00240082007f0055, 0x00cd00f2009c0008},
    {0x003d00d4000d009c, 0x00c60032004f007b, 0x00eb00de00160031, 0x00a300220077002f},
    {0x00af001000e10043, 0x003300b600760096, 0x00b900f600df0081, 0x00750018001c00ef},
    {0x004200c2000c00f3, 0x00ab00a800d20053, 0x006000d9008b0016, 0x00ca00ae0026004a},
    {0x000100bc00bd0001, 0x00bd000100bc00bd, 0x00bc00bd000100bc, 0x000100bc00bd0001},
    {0x003700cb00ec0034, 0x0020002600450093, 0x008600fb00d900de, 0x005300e3004e00ab},
    {0x0062003900ed0067, 0x00ef007800a20075, 0x000f00df006b00c7, 0x00b5002e00b600b3},
    {0x00bb00d800b100f9, 0x00cb0092002200a5, 0x00310086006000eb, 0x00c3004f000e00c2},
    {0x00c300cc005100d2, 0x0097009c00a9008a, 0x00ce000500820088, 0x00fc00f0001300e8},
};

/**
 * @brief Precomputed AVX2 table of \f$\alpha_i^j\f$ powers for syndrome accumulation (part 4/4).
 *
 * Each entry is one 256-bit block used by compute_syndromes() for a fixed
 * codeword position. The 16-bit lanes contain the GF(2^8) powers needed for
 * the final syndrome block.
 *
 * The table has \c PARAM_N1 - 1 entries, one for each non-constant codeword
 * coefficient processed during syndrome accumulation. Unused lanes in this
 * final block are zero-padded.
 */
static const __m256i alpha_ij_vecs_4[89] = {
    {0x0014000c000400f5, 0x004f00cc0044003c, 0x00000000006800d1, 0x0000000000000000},
    {0x000b005000100057, 0x00fe006100bb0027, 0x000000000087002b, 0x0000000000000000},
    {0x009c00ed0040003d, 0x008200ef00d50075, 0x00000000008900df, 0x0000000000000000},
    {0x004500b0001b00a5, 0x001200c600a80079, 0x00000000008f0029, 0x0000000000000000},
    {0x00330001006c0097, 0x000200d800350072, 0x0000000000e40066, 0x0000000000000000},
    {0x00d1000c00ab0026, 0x009e0008003b00cd, 0x0000000000db007f, 0x0000000000000000},
    {0x00d60050009a0081, 0x00e7003a00ae0087, 0x0000000000c000c3, 0x0000000000000000},
    {0x00ba00ed005e00e7, 0x001f002500b6009d, 0x0000000000cf002d, 0x0000000000000000},
    {0x008b00b00063006f, 0x00240039008c00f3, 0x0000000000a1000f, 0x0000000000000000},
    {0x0072000100970094, 0x0004006a006600d8, 0x00000000004d00d3, 0x0000000000000000},
    {0x00b2000c006a0022, 0x0027009a006b00a6, 0x0000000000fb0092, 0x0000000000000000},
    {0x002b005000b30078, 0x00d5004000320060, 0x00000000006f0089, 0x0000000000000000},
    {0x002a00ed00fa00a0, 0x003e00cb00fc0058, 0x000000000084008c, 0x0000000000000000},
    {0x003e00b000c5009b, 0x0048003300a2008f, 0x0000000000310034, 0x0000000000000000},
    {0x0035000100390036, 0x000800d300ab0066, 0x00000000001d00b3, 0x0000000000000000},
    {0x00a9000c00e40048, 0x004e007d00f900d0, 0x000000000064003d, 0x0000000000000000},
    {0x00ec005000bd00e0, 0x00b100bc00ed005d, 0x00000000005100b0, 0x0000000000000000},
    {0x00df00ed00c20092, 0x007c003600ca0043, 0x0000000000f70055, 0x0000000000000000},
    {0x000e00b00025002a, 0x00900002005500dd, 0x0000000000b900cd, 0x0000000000000000},
    {0x00d8000100940091, 0x0010008300d3006a, 0x0000000000fa002f, 0x0000000000000000},
    {0x0062000c0066002e, 0x009c00c2002b00db, 0x00000000000700b6, 0x0000000000000000},
    {0x00e9005000830068, 0x007900c5008200e2, 0x0000000000030085, 0x0000000000000000},
    {0x009b00ed003a0069, 0x00f8009700f30009, 0x0000000000b80037, 0x0000000000000000},
    {0x002900b000e8009c, 0x003b00ab007300c7, 0x00000000009200db, 0x0000000000000000},
    {0x00020001008d00cb, 0x0020001000080004, 0x0000000000800040, 0x0000000000000000},
    {0x0028000c000200f6, 0x00230074001600f0, 0x00000000008a00ca, 0x0000000000000000},
    {0x0016005000080053, 0x00f2004a00af009c, 0x000000000037002e, 0x0000000000000000},
    {0x002300ed002000c4, 0x00eb007200f200cf, 0x0000000000760067, 0x0000000000000000},
    {0x008a00b0008000e2, 0x007600d4003700ff, 0x00000000005b00ae, 0x0000000000000000},
    {0x0066000100360063, 0x0040002f00b300d3, 0x00000000004a00e8, 0x0000000000000000},
    {0x00b9000c00d80084, 0x0046008000c30019, 0x0000000000f800f2, 0x0000000000000000},
    {0x00b70050004d00eb, 0x00ff008d0007002a, 0x0000000000d70026, 0x0000000000000000},
    {0x006f00ed002f007f, 0x00cd006600c70042, 0x00000000001600b5, 0x0000000000000000},
    {0x000d00b000bc005d, 0x00ec00bd000c00e1, 0x0000000000b100ed, 0x0000000000000000},
    {0x00e4000100c60025, 0x008000fa001d004d, 0x000000000097004a, 0x0000000000000000},
    {0x007f000c00350085, 0x008c0063007500ae, 0x00000000005300a1, 0x0000000000000000},
    {0x0056005000d4001e, 0x00e5006c008b009b, 0x000000000027003b, 0x0000000000000000},
    {0x005400ed007d0028, 0x0081000400a1007b, 0x0000000000ac0060, 0x0000000000000000},
    {0x007c00b000ef0060, 0x00c3001d0067000a, 0x0000000000f300af, 0x0000000000000000},
    {0x006a000100910080, 0x001b009f002f0083, 0x0000000000020039, 0x0000000000000000},
    {0x0049000c00720012, 0x000300910089006d, 0x0000000000d000d9, 0x0000000000000000},
    {0x00c3005000d30038, 0x00d100350029006f, 0x00000000001500f9, 0x0000000000000000},
    {0x00a500ed006100a9, 0x0019004d000a0017, 0x000000000009009c, 0x0000000000000000},
    {0x001c00b0009f0087, 0x009d0020009e0059, 0x000000000005008b, 0x0000000000000000},
    {0x00ab0001004a00ef, 0x003600e800c200b3, 0x0000000000d30035, 0x0000000000000000},
    {0x00c4000c00330086, 0x0006009400430041, 0x0000000000ad0062, 0x0000000000000000},
    {0x00c9005000cc001a, 0x00b900e4007c00a5, 0x00000000009b0016, 0x0000000000000000},
    {0x002d00ed001d00d1, 0x003200b300d90024, 0x000000000085006f, 0x0000000000000000},
    {0x005200b000740027, 0x0021005e00b50031, 0x000000000059007c, 0x0000000000000000},
    {0x0004000100cb0074, 0x006c001b00400010, 0x00000000009a00ab, 0x0000000000000000},
    {0x0050000c000100b0, 0x000c000100b000ed, 0x0000000000ed0050, 0x0000000000000000},
    {0x002c005000040052, 0x006900cc000f0046, 0x0000000000de0075, 0x0000000000000000},
    {0x004600ed00100031, 0x0064006100d10011, 0x00000000001300a8, 0x0000000000000000},
    {0x000f00b0004000b5, 0x004200ef00a300d1, 0x0000000000620038, 0x0000000000000000},
    {0x00cc0001001b005e, 0x00d800c600ef0061, 0x00000000003a0008, 0x0000000000000000},
    {0x0069000c006c0021, 0x001800d800420064, 0x0000000000c800d2, 0x0000000000000000},
    {0x0075005000ab007c, 0x00d20008003800a8, 0x0000000000a20043, 0x0000000000000000},
    {0x00de00ed009a0059, 0x00c8003a00620013, 0x0000000000f500a2, 0x0000000000000000},
    {0x001a00b0005e00dc, 0x00840025006000a9, 0x0000000000690053, 0x0000000000000000},
    {0x00d30001006300c2, 0x00ab003900e8002f, 0x0000000000ef001d, 0x0000000000000000},
    {0x00fe000c009700ea, 0x0030006a0085008e, 0x00000000000e00d5, 0x0000000000000000},
    {0x00ac0050006a008a, 0x00bf009a0034005a, 0x0000000000060042, 0x0000000000000000},
    {0x00a800ed00b3000a, 0x008b0040007f00f7, 0x00000000006b0073, 0x0000000000000000},
    {0x00f800b000fa0018, 0x001300cb00150028, 0x00000000003f0078, 0x0000000000000000},
    {0x00d4000100c50020, 0x004d00330063003a, 0x00000000001b00c2, 0x0000000000000000},
    {0x0092000c00390089, 0x006000d3002400af, 0x00000000000f00fc, 0x0000000000000000},
    {0x009d005000e4000e, 0x0065007d005300a7, 0x00000000006e0024, 0x0000000000000000},
    {0x005100ed00bd00e1, 0x000d00bc0050005c, 0x0000000000ec000c, 0x0000000000000000},
    {0x003800b000c20067, 0x00260036009c007f, 0x0000000000b600bb, 0x0000000000000000},
    {0x004d00010025007d, 0x009a0002004a00fa, 0x00000000009400ef, 0x0000000000000000},
    {0x0093000c009400ac, 0x00c00083002e001f, 0x0000000000eb00f3, 0x0000000000000000},
    {0x008900500066008b, 0x00ca00c200cd00a2, 0x0000000000b500f7, 0x0000000000000000},
    {0x005a00ed008300ff, 0x001a00c500920090, 0x00000000002c009e, 0x0000000000000000},
    {0x00a400b0003a004f, 0x004c009700df00c4, 0x0000000000790032, 0x0000000000000000},
    {0x0008000100e8001d, 0x002f00ab00360040, 0x0000000000350063, 0x0000000000000000},
    {0x00a0000c008d002c, 0x009b001000f70099, 0x0000000000a600c7, 0x0000000000000000},
    {0x0058005000020099, 0x008f007400780003, 0x00000000004e0044, 0x0000000000000000},
    {0x008c00ed000800c7, 0x0034004a00d20044, 0x00000000004300a3, 0x0000000000000000},
    {0x001e00b0002000e6, 0x00980072006f0069, 0x0000000000fd0082, 0x0000000000000000},
    {0x008300010080009a, 0x005e00d40039009f, 0x0000000000040036, 0x0000000000000000},
    {0x00d2000c003600c3, 0x002d002f0026008b, 0x0000000000bb000a, 0x0000000000000000},
    {0x00ea005000d8001f, 0x0005008000db0096, 0x00000000002a006b, 0x0000000000000000},
    {0x00a700ed004d00dd, 0x0068008d003d004c, 0x0000000000120015, 0x0000000000000000},
    {0x003400b0002f0037, 0x002b0066002d0092, 0x00000000000a0007, 0x0000000000000000},
    {0x00bd000100bc00bd, 0x00bc00bd000100bc, 0x0000000000bd0001, 0x0000000000000000},
    {0x00e7000c00c600b7, 0x005a00fa0044000e, 0x00000000004100d1, 0x0000000000000000},
    {0x00430050003500af, 0x000a006300bb0073, 0x00000000002d002b, 0x0000000000000000},
    {0x004b00ed00d4008f, 0x00d0006c00d500f1, 0x00000000001100df, 0x0000000000000000},
    {0x00eb00b0007d0006, 0x0056000400a800a0, 0x0000000000b20029, 0x0000000000000000},
};

/**
 * Coefficients of polynomial G
 * stored in 256-bit values
 **/
static const __m256i rs_generator_vecs[4] = {
    {0x0034002300cb0023, 0x0049007d007900a5, 0x005200eb002a0088, 0x00620043007a00e8},
    {0x005200e600bc0033, 0x00b80067007500a4, 0x00b500f400da00d1, 0x008a0019000a007a},
    {0x009100e100b600d8, 0x008e000500f40064, 0x0096000f00ee00d5, 0x00de00f4001c003b},
    {0x003b007d005500fc, 0x002200b400d70034, 0x0000000100d000ad, 0x0000000000000000},
};

/**
 * @brief Precomputed evaluation powers for message positions (AVX2, 16-lane blocks).
 *
 * This table stores, for each polynomial power index \c j and each SIMD block of
 * message positions, the field elements needed to evaluate a polynomial at all
 * message points in parallel (used by Chien search and by polynomial evaluation
 * in Forney computations).
 *
 * Layout:
 *  - First dimension \c [PARAM_T + 1] :
 *      power index \c j in {0..PARAM_T}. Row \c j=0 is all ones.
 *  - Second dimension \c [POSITIONS_BLOCKS] :
 *      block index over message positions, where each block covers 16 positions.
 *      \c POSITIONS_BLOCKS = ceil(PARAM_K / 16).
 *  - Third dimension \c [16] :
 *      SIMD lane within a block (one lane per message position).
 */
__attribute__((aligned(32))) static const uint16_t beta_inv_pow_lanes[PARAM_T + 1][POSITIONS_BLOCKS][GF_LANES] = {
    {// power j = 0
     {1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1},
     {1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1}},
    {// power j = 1
     {244, 165, 99, 33, 31, 252, 84, 197, 67, 200, 177, 111, 37, 234, 175, 101},
     {35, 232, 88, 193, 182, 155, 128, 137, 142, 122, 223, 188, 157, 130, 126, 42}},
    {// power j = 2
     {86, 231, 194, 109, 78, 22, 160, 32, 174, 113, 236, 146, 125, 25, 163, 214},
     {105, 29, 240, 48, 249, 196, 154, 219, 206, 152, 127, 189, 208, 158, 136, 40}},
    {// power j = 3
     {158, 120, 8, 98, 59, 103, 205, 211, 209, 68, 12, 83, 171, 217, 38, 55},
     {52, 102, 10, 247, 115, 56, 53, 161, 46, 85, 15, 1, 199, 36, 162, 124}},
    {// power j = 4
     {164, 72, 53, 150, 255, 15, 246, 108, 162, 221, 13, 133, 141, 90, 243, 62},
     {134, 74, 70, 119, 7, 33, 197, 111, 101, 193, 137, 188, 42, 213, 218, 44}},
    {// power j = 5
     {198, 145, 74, 203, 27, 99, 197, 37, 232, 128, 188, 239, 159, 116, 64, 94},
     {250, 194, 58, 32, 47, 125, 97, 29, 16, 154, 179, 189, 131, 8, 77, 212}},
    {// power j = 6
     {213, 156, 64, 195, 50, 210, 96, 47, 43, 187, 80, 181, 179, 107, 120, 98},
     {103, 211, 68, 83, 217, 55, 102, 247, 56, 161, 85, 1, 36, 124, 242, 140}},
    {// power j = 7
     {11, 196, 179, 208, 24, 59, 178, 204, 83, 190, 92, 10, 216, 248, 85, 246},
     {253, 57, 138, 90, 66, 121, 203, 7, 84, 234, 182, 188, 100, 156, 201, 63}},
    {// power j = 8
     {230, 235, 102, 149, 19, 85, 82, 151, 242, 123, 81, 139, 203, 244, 67, 35},
     {142, 239, 191, 201, 21, 109, 32, 146, 214, 48, 219, 189, 40, 59, 110, 60}},
    {// power j = 9
     {124, 133, 54, 168, 202, 7, 67, 232, 223, 213, 237, 195, 194, 96, 146, 187},
     {249, 179, 158, 98, 205, 68, 171, 55, 10, 56, 46, 1, 162, 242, 41, 66}},
    {// power j = 10
     {37, 128, 239, 116, 94, 194, 32, 125, 29, 154, 189, 8, 212, 204, 171, 228},
     {2, 53, 51, 108, 57, 141, 198, 74, 27, 197, 232, 188, 159, 64, 250, 58}},
    {// power j = 11
     {160, 135, 29, 118, 208, 98, 110, 4, 38, 30, 225, 85, 108, 23, 41, 227},
     {70, 99, 234, 142, 213, 192, 250, 22, 173, 105, 181, 189, 241, 205, 20, 190}},
    {// power j = 12
     {59, 209, 171, 52, 115, 46, 199, 57, 41, 168, 176, 252, 232, 130, 156, 195},
     {210, 47, 187, 181, 107, 98, 211, 83, 55, 247, 161, 1, 124, 140, 66, 202}},
    {// power j = 13
     {150, 82, 57, 238, 134, 45, 200, 128, 213, 201, 93, 174, 97, 196, 107, 215},
     {104, 171, 229, 72, 85, 28, 148, 243, 207, 165, 175, 188, 191, 195, 78, 173}},
    {// power j = 14
     {69, 33, 232, 42, 91, 50, 233, 97, 181, 185, 224, 68, 106, 6, 161, 82},
     {23, 54, 222, 244, 175, 157, 116, 21, 160, 25, 249, 189, 215, 209, 112, 34}},
    {// power j = 15
     {64, 194, 47, 29, 179, 8, 211, 171, 102, 53, 1, 57, 54, 74, 99, 232},
     {239, 64, 194, 47, 29, 179, 8, 211, 171, 102, 53, 1, 57, 54, 74, 99}},
    {// power j = 16
     {73, 24, 211, 144, 30, 161, 180, 148, 66, 153, 177, 223, 116, 86, 174, 105},
     {206, 8, 184, 112, 10, 150, 108, 133, 62, 119, 111, 188, 44, 50, 147, 39}},
    {// power j = 17
     {92, 225, 1, 13, 81, 176, 177, 188, 237, 93, 236, 80, 189, 224, 12, 92},
     {225, 1, 13, 81, 176, 177, 188, 237, 93, 236, 80, 189, 224, 12, 92, 225}},
    {// power j = 18
     {140, 139, 99, 182, 117, 21, 174, 29, 127, 59, 12, 52, 53, 199, 133, 168},
     {7, 232, 213, 195, 96, 187, 179, 98, 68, 55, 56, 1, 242, 66, 45, 175}},
    {// power j = 19
     {142, 44, 194, 135, 196, 120, 184, 106, 115, 5, 13, 66, 27, 35, 213, 65},
     {233, 29, 220, 169, 83, 34, 114, 162, 238, 69, 67, 188, 192, 210, 25, 118}},
    {// power j = 20
     {125, 154, 8, 204, 228, 53, 108, 141, 74, 197, 188, 64, 58, 97, 179, 77},
     {4, 102, 114, 151, 54, 203, 37, 239, 94, 32, 29, 189, 212, 171, 2, 51}},
    {// power j = 21
     {209, 55, 53, 36, 41, 202, 111, 239, 195, 174, 80, 158, 211, 38, 56, 199},
     {140, 74, 67, 130, 61, 96, 29, 107, 205, 217, 115, 1, 133, 139, 252, 223}},
    {// power j = 22
     {246, 143, 74, 200, 42, 195, 147, 16, 120, 79, 92, 161, 151, 14, 45, 88},
     {191, 194, 25, 206, 59, 49, 2, 15, 167, 134, 252, 188, 71, 96, 11, 185}},
    {// power j = 23
     {165, 142, 64, 160, 11, 158, 104, 228, 161, 132, 81, 7, 128, 91, 22, 39},
     {208, 211, 89, 19, 162, 14, 27, 182, 44, 78, 187, 189, 178, 38, 95, 28}},
    {// power j = 24
     {50, 43, 179, 103, 217, 56, 36, 54, 45, 182, 237, 22, 29, 158, 209, 52},
     {46, 57, 168, 252, 130, 195, 47, 181, 98, 83, 247, 1, 140, 202, 175, 117}},
    {// power j = 25
     {131, 204, 102, 51, 148, 74, 37, 159, 194, 97, 189, 211, 228, 114, 57, 145},
     {197, 239, 250, 125, 179, 212, 106, 53, 151, 198, 99, 188, 94, 47, 154, 77}},
    {// power j = 26
     {149, 180, 54, 9, 142, 61, 113, 154, 59, 112, 225, 162, 198, 33, 130, 63},
     {135, 179, 76, 235, 161, 75, 145, 67, 100, 231, 163, 189, 184, 52, 255, 167}},
    {// power j = 27
     {66, 252, 239, 50, 163, 107, 209, 102, 15, 140, 176, 182, 64, 174, 181, 59},
     {217, 53, 124, 168, 67, 213, 194, 187, 158, 68, 10, 1, 41, 45, 137, 61}},
    {// power j = 28
     {186, 109, 29, 40, 245, 115, 28, 198, 252, 172, 93, 187, 131, 20, 247, 180},
     {14, 99, 126, 86, 163, 208, 204, 10, 246, 90, 7, 188, 63, 43, 220, 104}},
    {// power j = 29
     {240, 241, 171, 95, 221, 139, 234, 116, 96, 196, 224, 38, 114, 167, 202, 193},
     {201, 47, 206, 178, 52, 17, 141, 45, 122, 65, 43, 189, 79, 10, 82, 18}}};

/**
 * Returns i modulo the given modulus.
 * i must be less than 2*modulus.
 * Therefore, the return value is either i or i-modulus.
 * @returns i mod (modulus)
 * @param[in] i The integer whose modulo is taken
 * @param[in] modulus The modulus
 */
static inline uint16_t mod(uint16_t i, uint16_t modulus) {
    uint16_t tmp = i - modulus;

    // mask = 0xffff if(i < PARAM_GF_MUL_ORDER)
    int16_t mask = -(tmp >> 15);

    return tmp + (mask & modulus);
}

/**
 * @brief Constant-time nonzero mask for 16-bit values.
 *
 * Returns a full-bit mask:
 *  - \c 0xFFFF if \p x != 0
 *  - \c 0x0000 if \p x == 0
 *
 * @param x 16-bit input value.
 * @return 0xFFFF if \p x is nonzero, otherwise 0x0000.
 */
static inline uint16_t make_nonzero_mask(uint16_t x) {
    // 0xFFFF if x != 0 else 0x0000
    uint16_t CT_VOLATILE mask = (uint16_t)(-((x ^ (uint16_t)(-x)) >> 15));
    CT_OPAQUE(mask);
    return mask;
}

/**
 * @brief Constant-time zero test for an 8-bit value.
 *
 * Returns 1 if \p x is zero, else 0.
 *
 * @param x 8-bit input value.
 * @return 1 if \p x == 0, otherwise 0.
 */
static inline uint8_t is_zero(uint8_t x) {
    // returns 1 if x==0 else 0
    uint16_t CT_VOLATILE t = x;
    t |= (uint16_t)(-t);
    t = (((t >> 8) ^ 1) & 1);
    CT_OPAQUE(t);
    return (uint8_t)t;
}

/**
 * @brief Computes the generator polynomial of the primitive Reed-Solomon code with given parameters.
 *
 * Code length is 2^m-1. <br>
 * PARAM_T is the targeted correction capacity of the code
 * and receives the real correction capacity (which is at least equal to the target). <br>
 * gf_exp and gf_log are arrays giving antilog and log of GF(2^m) elements.
 *
 * @param[out] poly Array of size (2*PARAM_T + 1) receiving the coefficients of the generator polynomial
 */
void compute_generator_poly(uint16_t *poly) {
    poly[0] = 1;
    int tmp_degree = 0;

    for (uint16_t i = 1; i < (2 * PARAM_T + 1); ++i) {
        for (size_t j = tmp_degree; j; --j) {
            poly[j] = gf_exp[mod(gf_log[poly[j]] + i, PARAM_GF_MUL_ORDER)] ^ poly[j - 1];
        }

        poly[0] = gf_exp[mod(gf_log[poly[0]] + i, PARAM_GF_MUL_ORDER)];
        poly[++tmp_degree] = 1;
    }

    printf("\n");
    for (int i = 0; i < (PARAM_G); ++i) {
        printf("%d, ", poly[i]);
    }
    printf("\n");
}

/**
 * @brief Encode a message into a systematic Reed–Solomon codeword (AVX2-accelerated).
 *
 * Following @cite lin1983error (Chapter 4 - Cyclic Codes),
 * We perform a systematic encoding using a linear (PARAM_N1 - PARAM_K)-stage shift register
 * with feedback connections based on the generator polynomial PARAM_RS_POLY of the Reed-Solomon code.
 *
 * @param[out] cdw Array of size VEC_N1_SIZE_64 receiving the encoded message
 * @param[in] msg Array of size VEC_K_SIZE_64 storing the message
 */
void reed_solomon_encode(uint64_t *cdw, const uint64_t *msg) {
    uint8_t gate_value = 0;

    union {
        uint16_t terms[16 * CEIL_DIVIDE(PARAM_G, 16)];
        __m256i align;
    } feedback = {0};

    uint8_t msg_bytes[PARAM_K] = {0};
    uint8_t cdw_bytes[PARAM_N1] = {0};

    __m256i *feedback_vecs = (__m256i *)feedback.terms;

    memcpy(msg_bytes, msg, PARAM_K);

    for (int32_t i = PARAM_K - 1; i >= 0; --i) {
        gate_value = msg_bytes[i] ^ cdw_bytes[PARAM_N1 - PARAM_K - 1];
        __m256i gate_vec = _mm256_set1_epi16(gate_value);
        feedback_vecs[0] = gf_mul_vect(gate_vec, rs_generator_vecs[0]);
        feedback_vecs[1] = gf_mul_vect(gate_vec, rs_generator_vecs[1]);
        feedback_vecs[2] = gf_mul_vect(gate_vec, rs_generator_vecs[2]);
        feedback_vecs[3] = gf_mul_vect(gate_vec, rs_generator_vecs[3]);

        for (size_t k = PARAM_N1 - PARAM_K - 1; k; --k) {
            cdw_bytes[k] = cdw_bytes[k - 1] ^ feedback.terms[k];
        }

        cdw_bytes[0] = feedback.terms[0];
    }

    memcpy(cdw_bytes + PARAM_N1 - PARAM_K, msg_bytes, PARAM_K);
    memcpy(cdw, cdw_bytes, PARAM_N1);
}

/**
 * @brief Compute the 2·PARAM_T syndromes (AVX2).
 *
 * Evaluates the received codeword at consecutive powers of the field generator
 * using precomputed α^{i·j} tables packed in 256-bit vectors. The result is
 * written into \p syndrome_vecs (viewed as 16-bit lanes; only low bytes matter).
 *
 * @param[out] syndrome_vecs Output syndrome storage (AVX2 backing array).
 * @param[in]  cdw         Received codeword as bytes (\c PARAM_N1 bytes).
 */
static inline void compute_syndromes(__m256i *syndrome_vecs, const uint8_t *cdw) {
    uint16_t *syndromes = (uint16_t *)syndrome_vecs;

    syndrome_vecs[0] = _mm256_set1_epi16(cdw[0]);
    for (size_t i = 0; i < PARAM_N1 - 1; ++i) {
        syndrome_vecs[0] ^= gf_mul_vect(_mm256_set1_epi16(cdw[i + 1]), alpha_ij_vecs_1[i]);
    }

    syndrome_vecs[1] = _mm256_set1_epi16(cdw[0]);
    for (size_t i = 0; i < PARAM_N1 - 1; ++i) {
        syndrome_vecs[1] ^= gf_mul_vect(_mm256_set1_epi16(cdw[i + 1]), alpha_ij_vecs_2[i]);
    }

    syndrome_vecs[2] = _mm256_set1_epi16(cdw[0]);
    for (size_t i = 0; i < PARAM_N1 - 1; ++i) {
        syndrome_vecs[2] ^= gf_mul_vect(_mm256_set1_epi16(cdw[i + 1]), alpha_ij_vecs_3[i]);
    }

    __m256i last_syndrome_vecs = _mm256_set1_epi16(cdw[0]);
    for (size_t i = 0; i < PARAM_N1 - 1; ++i) {
        last_syndrome_vecs ^= gf_mul_vect(_mm256_set1_epi16(cdw[i + 1]), alpha_ij_vecs_4[i]);
    }

    memcpy(syndromes + 48, &last_syndrome_vecs, 10 * sizeof(uint16_t));

#ifdef VERBOSE
    printf("\n\nThe syndromes: ");
    for (size_t i = 0; i < 2 * PARAM_T; ++i) {
        printf("%u ", (unsigned)(syndromes[i] & 0xFF));
    }
#endif
}

/**
 * @brief Compute the Reed–Solomon error-locator polynomial (constant-time Berlekamp–Massey).
 *
 * @param[out] sigma     Error-locator polynomial, \c PARAM_T+1 GF(2^8) coefficients.
 * @param[in]  syndrome  Syndromes \f$S_0,\ldots,S_{2\,\texttt{PARAM\_T}-1}\f$.
 */
static inline void compute_error_locator_polynomial(uint16_t *sigma, const uint16_t *syndrome) {
    uint16_t deg_sigma = 0;
    uint16_t sigma_mu[PARAM_T + 1] = {0};
    uint16_t deg_sigma_mu = 0;
    uint16_t x_sigma_rho[PARAM_T + 1] = {0, 1};
    uint16_t deg_sigma_rho = 0;
    uint16_t rho = (uint16_t)-1;
    uint16_t d_rho = 1;
    uint16_t d_mu = syndrome[0];
    uint16_t mu, i;

    sigma[0] = 1;
    for (mu = 0; mu < (2 * PARAM_T); ++mu) {
        uint16_t d_nonzero_mask = (uint16_t)(-((uint16_t)-d_mu >> 15));

        memcpy(sigma_mu, sigma, sizeof sigma_mu);
        deg_sigma_mu = deg_sigma;

        uint16_t d_mu_over_d_rho = gf_mul(d_mu, gf_inverse(d_rho));
        for (i = 1; (i <= mu + 1) && (i <= PARAM_T); ++i) {
            sigma[i] ^= gf_mul(d_mu_over_d_rho, x_sigma_rho[i]);
        }

        uint16_t deg_x_sigma_rho = (uint16_t)((uint16_t)(mu - rho) + deg_sigma_rho);

        uint16_t deg_would_grow_mask = (uint16_t)(-((uint16_t)(deg_sigma_mu - deg_x_sigma_rho) >> 15));

        volatile uint16_t promote_mask__ = d_nonzero_mask & deg_would_grow_mask;
        uint16_t promote_mask = promote_mask__;

        deg_sigma ^= promote_mask & (deg_x_sigma_rho ^ deg_sigma);

        for (i = PARAM_T; i; --i) {
            x_sigma_rho[i] = (promote_mask & sigma_mu[i - 1]) ^ (~promote_mask & x_sigma_rho[i - 1]);
        }
        deg_sigma_rho ^= promote_mask & (deg_sigma_mu ^ deg_sigma_rho);
        rho ^= promote_mask & (mu ^ rho);
        d_rho ^= promote_mask & (d_mu ^ d_rho);

        if (mu + 1 < 2 * PARAM_T) {
            d_mu = syndrome[mu + 1];
            for (i = 1; (i <= mu + 1) && (i <= PARAM_T); ++i) {
                d_mu ^= gf_mul(sigma[i], syndrome[mu + 1 - i]);
            }
        }
    }

    memset_zero(sigma_mu, sizeof sigma_mu);
    memset_zero(x_sigma_rho, sizeof x_sigma_rho);

#ifdef VERBOSE
    printf("\n\nThe error locator polynomial: sigma(x) = ");
    bool first_coeff = true;
    for (size_t i = 0; i <= PARAM_T; ++i) {
        uint16_t c = (uint16_t)(sigma[i] & 0xFF);
        if (c == 0)
            continue;

        if (!first_coeff)
            printf(" + ");
        first_coeff = false;

        if (i == 0) {
            printf("%u", (unsigned)c);
        } else {
            if (c != 1)
                printf("%u*", (unsigned)c);
            if (i == 1)
                printf("x");
            else
                printf("x^%zu", i);
        }
    }
    if (first_coeff)
        printf("0");
#endif
}

/**
 * @brief Compute error positions on the message part using Chien search (AVX2).
 *
 * Evaluates the error-locator polynomial \f$\sigma(x)\f$ at all message evaluation
 * points and outputs a 0/1 flag per message position indicating whether that
 * position is a root (hence an error location).
 *
 * The output layout is message-only:
 * - \c error_positions[i] corresponds to the message byte at codeword index
 *   \c (PARAM_N1 - PARAM_K + i).
 *
 * This implementation processes message positions in fixed 16-lane AVX2 blocks
 * using the precomputed table \c beta_inv_pow_lanes.
 *
 * @param[out] error_positions Output error flags (size \c PARAM_K), each entry is 0 or 1.
 * @param[in]  sigma   Error-locator polynomial coefficients (size \c PARAM_T+1).
 */
static inline void compute_error_positions(uint8_t *error_positions, const uint16_t *sigma) {
    const __m256i vzero = _mm256_setzero_si256();
    const __m256i sigma_zero_vec = _mm256_set1_epi16((uint16_t)(sigma[0] & 0xFF));

    uint8_t flags[POSITIONS_BLOCKS * GF_LANES];

    for (size_t pos_blk = 0; pos_blk < POSITIONS_BLOCKS; ++pos_blk) {
        __m256i sigma_eval = sigma_zero_vec;

        for (size_t coef_idx = 1; coef_idx <= PARAM_T; ++coef_idx) {
            const __m256i sigma_coeff_vec = _mm256_set1_epi16((uint16_t)(sigma[coef_idx] & 0xFF));

            const __m256i eval_pow_vec = _mm256_loadu_si256((const __m256i *)beta_inv_pow_lanes[coef_idx][pos_blk]);

            const __m256i prod = gf_mul_vect(sigma_coeff_vec, eval_pow_vec);
            sigma_eval = _mm256_xor_si256(sigma_eval, prod);
        }

        const __m256i is_root_mask = _mm256_cmpeq_epi16(sigma_eval, vzero);

        uint16_t root_mask_lanes[GF_LANES];
        _mm256_storeu_si256((__m256i *)root_mask_lanes, is_root_mask);

        for (size_t lane = 0; lane < GF_LANES; ++lane) {
            flags[pos_blk * GF_LANES + lane] = (uint8_t)((root_mask_lanes[lane] >> 15) & 1u);
        }
    }

    memcpy(error_positions, flags, PARAM_K);
    memset_zero(flags, sizeof flags);
}

/**
 * @brief Evaluate a polynomial at all message evaluation points (AVX2).
 *
 * Computes \f$y_i = \mathrm{poly}(x_i)\f$ for every message position \f$i \in [0, \texttt{PARAM\_K}-1]\f$
 * using AVX2 over 16 positions at a time. The evaluation points \f$x_i\f$ (with the same neg/pos
 * convention used by this RS implementation) are provided by the precomputed table
 * \c beta_inv_pow_lanes.
 *
 * Output layout is message-only:
 * - \c out[i] corresponds to message index \c i (i.e., codeword index \c PARAM_N1-PARAM_K+i).
 *
 * @param[out] out  Output array of size \c PARAM_K holding \f$\mathrm{poly}(x_i)\f$ (GF(2^8) in low byte).
 * @param[in]  poly Polynomial coefficients, size \c PARAM_T+1 (GF(2^8) in low byte).
 */
static inline void evaluate_poly_at_all_msg_points(uint8_t *out, const uint16_t *poly) {
    uint16_t eval_lanes[GF_LANES];
    uint8_t outbuf[POSITIONS_BLOCKS * GF_LANES];
    for (size_t b = 0; b < POSITIONS_BLOCKS; ++b) {
        __m256i acc = _mm256_set1_epi16((uint16_t)(poly[0] & 0xFF));
        for (uint16_t j = 1; j <= PARAM_T; ++j) {
            __m256i cj = _mm256_set1_epi16((uint16_t)(poly[j] & 0xFF));
            __m256i xj = _mm256_loadu_si256((const __m256i *)&beta_inv_pow_lanes[j][b][0]);
            __m256i prd = gf_mul_vect(cj, xj);
            acc ^= prd;
        }

        _mm256_storeu_si256((__m256i *)eval_lanes, acc);
        for (size_t l = 0; l < GF_LANES; ++l) outbuf[b * GF_LANES + l] = (uint8_t)(eval_lanes[l] & 0xFF);
    }
    memcpy(out, outbuf, PARAM_K);
    memset_zero(outbuf, sizeof outbuf);
}

/**
 * @brief Constant-time batch inversion in GF(2^8).
 *
 * Inverts all PARAM_K elements with a single field inversion:
 * \f$\mathrm{inv}[i] = \big(\prod_{k<i} a[k]\big)\big(\prod_{k>i} a[k]\big)\big(\prod_k a[k]\big)^{-1}\f$.
 * Zero inputs are mapped to 1 so 0 is never inverted.
 *
 * @param[out] inv Output inverses (size \c PARAM_K).
 * @param[in]  a   Input elements (size \c PARAM_K).
 */
static inline void batch_inverse(uint8_t *inv, const uint8_t *a) {
    uint8_t prefix[PARAM_K];
    uint8_t acc = 1;

    for (size_t i = 0; i < PARAM_K; i++) {
        uint8_t a_is_zero = is_zero(a[i]);
        uint8_t safe_a = (uint8_t)(a[i] | a_is_zero);

        prefix[i] = acc;
        acc = gf_mul(acc, safe_a);
    }

    uint8_t inv_all = (uint8_t)gf_inverse(acc);
    uint8_t suffix = 1;
    for (size_t i = PARAM_K; i-- > 0;) {
        uint8_t a_is_zero = is_zero(a[i]);
        uint8_t safe_a = (uint8_t)(a[i] | a_is_zero);
        uint8_t prod_except_i = gf_mul(prefix[i], suffix);
        inv[i] = gf_mul(prod_except_i, inv_all);
        suffix = gf_mul(suffix, safe_a);
    }
}

/**
 * @brief Compute error values on message positions and output the corrected message.
 *
 * This function computes the error magnitudes and applies corrections only for
 * the message bytes, which are stored in the last PARAM_K bytes of the
 * received Reed-Solomon codeword.
 *  1) Compute the auxiliary polynomial Z(x) from \p syndromes and \p sigma.
 *  2) Form the odd part \f$\sigma_{\text{odd}}(x)\f$ (formal derivative in GF(2^8)).
 *  3) Evaluate Z and \f$\sigma_{\text{odd}}\f$ at all message points, batch-invert the
 *     denominators, and compute error values for positions marked in
 *     \p error_positions.
 *  4) Correct the message bytes: \c message[i] = cdw_tail[i] XOR error_value[i].
 *
 * @param[out] message          Decoded message (size \c PARAM_K).
 * @param[in]  cdw_bytes        Received codeword bytes (size \c PARAM_N1).
 * @param[in]  syndromes        Syndromes \f$S_0..S_{2t-1}\f$ (low bytes used).
 * @param[in]  sigma            Error-locator polynomial (size \c PARAM_T+1).
 * @param[in]  error_positions  Message-only error flags (size \c PARAM_K, entries 0/1).
 */
static inline void correct_errors(uint8_t *message, const uint8_t *cdw_bytes, const uint16_t *syndromes,
                                  const uint16_t *sigma, const uint8_t *error_positions) {
    uint16_t z[PARAM_T + 1] = {0};
#ifdef VERBOSE
    uint8_t error_values[PARAM_K] = {0};
#endif
    z[0] = 1;

    for (uint16_t i = 0; i < PARAM_T; ++i) {
        z[i + 1] = syndromes[i];

        for (uint16_t j = 0; j < i; ++j) {
            uint16_t sj1 = sigma[j + 1];
            uint16_t sj2 = syndromes[i - 1 - j];
            z[i + 1] ^= gf_mul(sj1, sj2);
        }

        z[i + 1] ^= sigma[i + 1];
    }

    uint16_t sigma_odd[PARAM_T + 1] = {0};
    for (uint16_t i = 1; i <= PARAM_T; i += 2) {
        sigma_odd[i] = sigma[i];
    }

    uint8_t numerator_array[PARAM_K] = {0};
    uint8_t denominator_array[PARAM_K] = {0};
    evaluate_poly_at_all_msg_points(numerator_array, z);
    evaluate_poly_at_all_msg_points(denominator_array, sigma_odd);

    uint8_t inverse_denominator_array[PARAM_K] = {0};
    batch_inverse(inverse_denominator_array, denominator_array);

    for (size_t i = 0; i < PARAM_K; ++i) {
        uint16_t has_error = make_nonzero_mask((uint16_t)error_positions[i]);
        uint16_t den_nonzero = make_nonzero_mask((uint16_t)denominator_array[i]);
        uint16_t valid = has_error & den_nonzero;

        uint8_t mag = gf_mul(numerator_array[i], inverse_denominator_array[i]);
        uint8_t corr = (uint8_t)(valid & mag);
        message[i] = cdw_bytes[i + (PARAM_N1 - PARAM_K)] ^ corr;
#ifdef VERBOSE
        error_values[i] = corr;
#endif
    }

#ifdef VERBOSE
    printf("\n\nThe polynomial: Z(x) = ");
    bool first_z = true;
    for (size_t i = 0; i <= PARAM_T; ++i) {
        uint16_t c = (uint16_t)(z[i] & 0xFF);
        if (c == 0)
            continue;

        if (!first_z)
            printf(" + ");
        first_z = false;

        if (i == 0) {
            printf("%u", (unsigned)c);
        } else {
            if (c != 1)
                printf("%u*", (unsigned)c);
            if (i == 1)
                printf("x");
            else
                printf("x^%zu", i);
        }
    }
    if (first_z)
        printf("0");

    printf("\n\nError locations / magnitudes: ");
    size_t n_err = 0;
    for (size_t i = 0; i < PARAM_K; ++i) {
        n_err += (error_positions[i] != 0);
    }

    if (n_err == 0) {
        printf("none (no errors detected in message positions)\n");
    } else {
        printf("%zu error%s: ", n_err, (n_err == 1) ? "" : "s");
        for (size_t i = 0; i < PARAM_K; ++i) {
            if (error_positions[i]) {
                size_t pos_cw = (size_t)(PARAM_N1 - PARAM_K) + i;
                printf("(%zu, %u) ", pos_cw, (unsigned)error_values[i]);
            }
        }
        printf("\nMessage indices: ");
        for (size_t i = 0; i < PARAM_K; ++i) {
            if (error_positions[i])
                printf("%zu ", i);
        }
        printf("\n");
    }
#endif

    memset_zero(z, sizeof z);
    memset_zero(sigma_odd, sizeof sigma_odd);
    memset_zero(numerator_array, sizeof numerator_array);
    memset_zero(denominator_array, sizeof denominator_array);
    memset_zero(inverse_denominator_array, sizeof inverse_denominator_array);
}

/**
 * @brief Decode a Reed–Solomon codeword and recover the message (message-only correction).
 *
 * Steps:
 *  1) Copy the received codeword (\p cdw) into a local byte buffer.
 *  2) Compute the 2·PARAM_T syndromes.
 *  3) Run Berlekamp–Massey to compute the error-locator polynomial σ(x).
 *  4) Run Chien search over the message positions to get \p error_positions (0/1 flags).
 *  5) Compute z(x), error values (Forney), and correct the message bytes.
 *  6) Copy the corrected message to \p msg and zeroize temporary buffers.
 *
 * @param[out] msg Output message buffer (expects \c PARAM_K bytes).
 * @param[in]  cdw Input codeword buffer (expects \c PARAM_N1 bytes).
 */
void reed_solomon_decode(uint64_t *msg, uint64_t *cdw) {
    uint8_t cdw_bytes[PARAM_N1] = {0};
    __m256i syndrome_vecs[SYND_VEC_COUNT];
    uint16_t *syndromes = (uint16_t *)syndrome_vecs;
    uint16_t sigma[PARAM_T + 1] = {0};
    uint8_t error_positions[PARAM_K] = {0};
    uint8_t message[PARAM_K] = {0};

    memcpy(cdw_bytes, cdw, PARAM_N1);

    compute_syndromes(syndrome_vecs, cdw_bytes);
    compute_error_locator_polynomial(sigma, syndromes);
    compute_error_positions(error_positions, sigma);
    correct_errors(message, cdw_bytes, syndromes, sigma, error_positions);

    memcpy(msg, message, PARAM_K);

    memset_zero(cdw_bytes, sizeof cdw_bytes);
    memset_zero(syndrome_vecs, sizeof syndrome_vecs);
    memset_zero(sigma, sizeof sigma);
    memset_zero(error_positions, sizeof error_positions);
    memset_zero(message, sizeof message);
}
